# IAR project EntranceAutomation.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: g:\STM8\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\inc; G:\EntranceAutomation\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: EntranceAutomation.srec
  ILINK.IlinkOutputFile: EntranceAutomation.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group src
    ../../src/: main.c main.h stm8s.h stm8s_conf.h stm8s_it.c stm8s_it.h
  group STM8S10x_std_hal
    ../../../STM8/STM8S_StdPeriph_Lib/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
